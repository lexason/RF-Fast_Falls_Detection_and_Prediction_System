options:
  parameters:
    author: CARAT
    comment: File-backed CW Doppler IQ source. Publishes over ZMQ PUB so every downstream DSP/inference stage runs identically whether the source is this replay flowgraph or the live USRP CW Doppler acquisition flowgraph. Throttled to samp_rate so replay timing matches a live capture.
    description: Replay a recorded IQ session (SigMF-format .sigmf-data, raw interleaved complex64) over ZMQ PUB for hardware-free downstream development.
    generate_options: no_gui
    id: replay_source
    output_language: python
    title: CARAT Replay Source
  states: {}

blocks:
- name: iq_file
  id: parameter
  parameters:
    comment: Path to a .sigmf-data file (raw interleaved complex64, little-endian)
    label: IQ file path
    type: str
    value: ''
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: Must match the session's recorded sample rate (see manifest.json)
    label: Sample rate (sps)
    type: eng_float
    value: '250000'
  states: {}
- name: zmq_addr
  id: parameter
  parameters:
    comment: ZMQ PUB bind address consumed by dsp/ services
    label: ZMQ PUB address
    type: str
    value: tcp://127.0.0.1:5555
  states: {}
- name: repeat
  id: parameter
  parameters:
    comment: 'True: loop the file (useful for soak-testing dsp/); False: play once'
    label: Repeat file
    type: str
    value: 'False'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: iq_file
    repeat: repeat
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Paces replay to real-time so downstream STFT/state-machine timing behaves the same as a live capture
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_addr
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
